# IAR project Project.ewp, settings and files
configuration STM32F429_439xx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\; $PROJ_DIR$; ..\..\STM32F4xx_StdPeriph_Driver\inc; ..; ..\sd_card\FatFS; ..\sd_card
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../: system_stm32f4xx.c
  group EWARM
    ./: startup_stm32f429_439xx.s
  group sdcard
    ../sd_card/FatFS/: diskio.c ff.c
    ../sd_card/: sd_card_reader.c sdcard.c syscall.c
  group STM32F4xx_StdPeriph_Driver
    ../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c
  group User
    ../: 32f429_lcd.c 32f429_sdram.c main.c stm32f4xx_it.c
